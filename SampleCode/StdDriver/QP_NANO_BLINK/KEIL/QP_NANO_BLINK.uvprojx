# Keil uVision project QP_NANO_BLINK.uvprojx, settings and files
target GPIO_OutputInput (6220000::V6.22::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: QP_NANO_BLINK
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\QP_NANO_BLINK;..\qpn-master\ports\arm-cm\qv\arm;..\qpn-master\include
  asm include: ..\qpn-master\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
  group QP_PORT
    ../qpn-master/ports/arm-cm/qv/arm/: qvn_port.c
  group QP_SRC
    ../qpn-master/src/qfn/: qepn.c qfn.c
    ../qpn-master/src/qvn/: qvn.c
  group QP_INCLUDE
    ../qpn-master/include/: qstamp.c
software components: CMSIS:CORE 5.1.2
